require linux-yocto-amd-zynq.inc

KBRANCH:amd-zynq  = "v6.18/standard/xlnx-soc"
